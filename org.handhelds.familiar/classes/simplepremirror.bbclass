PREMIRRORS_prepend () {
ftp://.*/.*/  ${LOCAL_MIRROR}
http://.*/.*/  ${LOCAL_MIRROR}
}
